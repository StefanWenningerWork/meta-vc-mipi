IMAGE_INSTALL:append = " v4l2-test"